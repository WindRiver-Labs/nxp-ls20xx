COMPATIBLE_MACHINE_nxp-ls20xx = "nxp-ls20xx"
COMPATIBLE_HOST_nxp-ls20xx = "(aarch64).*-linux"
