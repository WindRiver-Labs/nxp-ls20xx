COMPATIBLE_MACHINE = "nxp-ls20xx"
