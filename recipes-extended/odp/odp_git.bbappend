COMPATIBLE_MACHINE_nxp-ls20xx = "nxp-ls20xx"
COMPATIBLE_HOST = "(aarch64).*-linux"
