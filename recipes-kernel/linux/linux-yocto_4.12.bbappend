require linux-yocto-nxp-ls20xx.inc

KBRANCH_nxp-ls20xx  = "standard/nxp-ls/lsdk-1709/${KMACHINE}"
