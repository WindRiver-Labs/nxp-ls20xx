require linux-yocto-nxp-ls20xx.inc

KBRANCH_nxp-ls20xx  = "v4.18/standard/preempt-rt/nxp-ls/lsdk-1812/${KMACHINE}"
