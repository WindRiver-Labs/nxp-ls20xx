require linux-yocto-nxp-ls20xx.inc

KBRANCH_nxp-ls20xx  = "v5.2/standard/nxp-lsdk-20.04/nxp-ls20xx"
