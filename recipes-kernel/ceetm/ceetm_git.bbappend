COMPATIBLE_MACHINE_nxp-ls20xx = "nxp-ls20xx"
PACKAGE_ARCH_nxp-ls20xx = "${MACHINE_ARCH}"
COMPATIBLE_HOST_nxp-ls20xx = "(aarch64).*-linux"
